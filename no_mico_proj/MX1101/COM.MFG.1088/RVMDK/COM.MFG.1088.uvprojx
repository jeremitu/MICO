# Keil uVision project COM.MFG.1088.uvprojx, settings and files
target MicoKit-3088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: COM.MFG.3088.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MFG.1088\MiCOKit-3088\Obj_RVMDK\COM.MFG.3088.axf --output ..\..\..\..\Build\COM.MFG.1088\Output\MiCOKit-3088\COM.MFG.3088.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG MFG_MODE
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\MicoKit-3088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals
  memory RVCT4: ROM 0x5b000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238,L6436W,L6432W,L6433W --no_strict_wchar_size  --no_strict_enum_size
  group Application
    ../../../../Demos/COM.MFG.1088/: main.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group MICO/Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm3_mfg.a
  group Support
    ../../../../Support/: RingBufferUtils.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/MCU/MX1101/RVMDK
    ../../../../Platform/MCU/MX1101/RVMDK/: startup_mx1101.s
  group Platform/MCU/MX1101/EMW1062
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/MCU/MX1101/EMW1088
    ../../../../Platform/MCU/MX1101/EMW1088_Driver/: read_wifi_firmware.c wlan_bus.c wlan_platform.c
  group Platform/MCU/MX1101/peripherals
    ../../../../Platform/MCU/MX1101/peripherals/: MicoDriverAdc.c MicoDriverCommon.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c
  group Platform/MCU/MX1101/peripherals/Libraries
    ../../../../Platform/MCU/MX1101/peripherals/Libraries/: driver.lib
  group Board/MX1101_EVB
    ../../../../Board/MX1101_EVB/: platform.c platform.h platform_common_config.h
  group Board/MicoKit-3088
    ../../../../Board/MiCOKit-3088/: platform.c platform.h platform_common_config.h
  group Board/EMW5088
    ../../../../Board/EMW5088/: platform.c
  group Platform/MCU/MX1101/filesystem
    ../../../../Platform/MCU/MX1101/FileSystem/: diskio.c filesort.c fs.lib partition.c presearch.c
target EMW5088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MFG.5088.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MFG.1088\EMW5088\Obj_RVMDK\COM.MFG.5088.axf --output ..\..\..\..\Build\COM.MFG.1088\Output\EMW5088\COM.MFG.5088.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG MFG_MODE
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\EMW5088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\Platform\MCU\MX1101\FileSystem\inc
  memory RVCT4: ROM 0x5b000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: as above
