# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3162; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3162\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICOKit-F205 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-F205; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-F205\bootloaderLinkerForIAR.icf
configuration MiCOKit-3161 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3161; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3161\bootloaderLinkerForIAR.icf
configuration MiCOKit-G55 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel ATSAMG55J19
  ICCARM.CCDefines: __SAMG55J19__; ARM_MATH_CM4=true; BOARD=SAMG55_XPLAINED_PRO; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-G55; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\utils; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\utils\preprocessor; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\utils\header_files; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\samg55\include; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\clock; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\boards; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\sleepmgr; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\delay; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\ioport; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\utils\fpu; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\serial; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\services\flash_efc; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals; ..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\inc
  ILINK.IlinkIcfFile: Y:\Develop\MiCO\Board\MiCOKit-G55\bootloaderLinkerForIAR.icf
  group Board/MiCOKit-G55
    ../../../../Board/MiCOKit-G55/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c MicoDefaults.h Update_for_OTA.c ymodem.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STSAMG55
    ../../../../Platform/MCU/ATSAMG55/: platform_init.c
  group Platform/MCU/STSAMG55/EWARM
    ../../../../Platform/MCU/ATSAMG55/EWARM/: startup_ATSAMG55_bootloader_EWARM.s
  group Platform/MCU/STSAMG55/Peripherals
    ../../../../Platform/MCU/ATSAMG55/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/: system_samg55.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/common
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/services/clock/samg/: sysclk.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/sam/drivers
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/sam/drivers/src/: efc.c flexcom.c gpbr.c pdc.c pio.c pio_handler.c pmc.c rtc.c sleep.c smc.c spi.c spi_master_vec.c supc.c twi.c uart.c usart.c wdt.c
  group Platform/MCU/STSAMG55/Peripherals/Libraries/sam/services
    ../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/sam/services/flash_efc/: flash_efc.c
  group Support
    ../../../../Support/: RingBufferUtils.c StringUtils.c
